HOMEPAGE = "http://www.audiocoding.com/faac.html"

LICENSE_FLAGS = "commercial"
