SRC_URI = "git://git.yoctoproject.org/${BPN}-2 \
	file://vfolders/All.directory \
	file://vfolders/Applications.directory \
	file://vfolders/Games.directory \
	file://vfolders/Root.order \
	file://vfolders/Settings.directory \
	"
