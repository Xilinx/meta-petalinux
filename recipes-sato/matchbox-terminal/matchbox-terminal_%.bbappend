SRC_URI_append = " file://0001-main.c-Add-support-to-run-user-command-inside-the-te.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
