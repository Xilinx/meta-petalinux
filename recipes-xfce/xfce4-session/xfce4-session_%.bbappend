ALTERNATIVE_PRIORITY_${PN} = "90"
