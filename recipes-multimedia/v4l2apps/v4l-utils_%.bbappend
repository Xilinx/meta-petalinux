SRC_URI_append = " file://0001-v4l-utils-Add-support-for-new-media-bus-codes.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
