inherit distutils-base

