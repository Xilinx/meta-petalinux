PNBLACKLIST[opencv] = "OpenCV 4.1 is not supported."
