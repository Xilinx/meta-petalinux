RDEPENDS_${PN}_remove_microblazeel = "\
    gdb \
    gdbserver \
"
