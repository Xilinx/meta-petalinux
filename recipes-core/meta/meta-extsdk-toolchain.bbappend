DEPENDS += "libyaml-native python3-cython-native python3-pyyaml-native"
