FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://scale-voltage-current.patch"

