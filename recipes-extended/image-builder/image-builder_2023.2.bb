BRANCH = "xlnx_rel_v2023.2"
SRCREV = "62198dfd173fd7a8b19d25b0e5de2a35fbd0a22d"

include image-builder.inc
