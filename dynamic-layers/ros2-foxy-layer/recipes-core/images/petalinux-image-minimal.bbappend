require petalinux-image-common-ros2.inc
