FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://pseudo-Work-around-issues-with-glibc-2.24.patch"
