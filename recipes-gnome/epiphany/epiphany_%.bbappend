DEPENDS += "libsecret"
