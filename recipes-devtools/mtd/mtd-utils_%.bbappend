FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-Update-mkfs.jffs-to-support-4K-erase-block.patch"
