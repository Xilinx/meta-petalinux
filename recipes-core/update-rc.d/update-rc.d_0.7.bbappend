BBCLASSEXTEND += " nativesdk"
