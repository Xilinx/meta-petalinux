SRCREV = "684e18c927e89615c2d501737e90018f4930d6c5"
PV = "2.14.0+git${SRCPV}"

SRC_URI = "git://github.com/akheron/jansson.git;branch=master;protocol=http"

S = "${WORKDIR}/git"
