require petalinux-image-common-provencore.inc
