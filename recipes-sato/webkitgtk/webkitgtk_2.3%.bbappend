FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-egl-GLContextEGL.cpp-Check-the-spported-EGL-version-.patch"
