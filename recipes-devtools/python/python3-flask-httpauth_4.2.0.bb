SUMMARY = "Basic and Digest HTTP authentication for Flask routes"
DESCRIPTION = "Simple extension that provides Basic and Digest HTTP authentication for Flask routes."
HOMEPAGE = "https://github.com/miguelgrinberg/flask-httpauth/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b69377f79f3f48c661701236d5a6a85"

SRC_URI[md5sum] = "a26c7bf69a9f2caa1ff3a32c12a0967b"
SRC_URI[sha256sum] = "8c7e49e53ce7dc14e66fe39b9334e4b7ceb8d0b99a6ba1c3562bb528ef9da84a"

PYPI_PACKAGE = "Flask-HTTPAuth"
inherit pypi setuptools3
