MIRRORS += "\
git://xenbits.xen.org/xen.git git://xenbits.xen.org/git-http/xen.git;protocol=https \n \
git://git.eclipse.org/gitroot/tcf/org.eclipse.tcf.agent git://git.eclipse.org/r/tcf/org.eclipse.tcf.agent;protocol=https \n \
"

