LIC_FILES_CHKSUM:append = " file://README;md5=0eee580528145c2bccaf37ed83c5c6c0"
