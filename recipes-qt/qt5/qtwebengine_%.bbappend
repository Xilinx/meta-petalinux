PACKAGECONFIG_append = " ffmpeg"
