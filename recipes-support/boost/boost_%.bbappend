PACKAGECONFIG = "locale python"
