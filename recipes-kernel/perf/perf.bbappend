do_populate_lic[depends] = "virtual/kernel:do_configure"
do_unpack[depends] = "virtual/kernel:do_configure"
