# Microblaze does not support the following tools
PERF:microblaze = ""
SYSTEMTAP:microblaze = ""
LTTNGTOOLS:microblaze = ""
BABELTRACE:microblaze = ""
BABELTRACE2:microblaze = ""
VALGRIND:microblaze = ""
