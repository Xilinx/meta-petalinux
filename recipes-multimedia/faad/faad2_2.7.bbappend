LIC_FILES_CHKSUM_append = " file://README;md5=38b6babe7418e791f75b899f72d574a9"
