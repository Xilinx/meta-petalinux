PACKAGECONFIG:append = " tui"
