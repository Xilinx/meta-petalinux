require recipes-core/meta/buildtools.inc

TOOLCHAIN_HOST_TASK += "\
	nativesdk-libyaml-dev \
	nativesdk-zlib-dev \
	nativesdk-ncurses-dev \
"
