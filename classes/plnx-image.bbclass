FEATURE_PACKAGES_petalinux-x11 = "packagegroup-core-x11"
FEATURE_PACKAGES_petalinux-x11[optional] = "1"
FEATURE_PACKAGES_petalinux-matchbox = "packagegroup-xilinx-matchbox"
FEATURE_PACKAGES_petalinux-matchbox[optional] = "1"
FEATURE_PACKAGES_petalinux-weston = "packagegroup-core-weston"
FEATURE_PACKAGES_petalinux-weston[optional] = "1"
FEATURE_PACKAGES_petalinux-self-hosted = "packagegroup-self-hosted vim"
FEATURE_PACKAGES_petalinux-self-hosted[optional] = "1"
FEATURE_PACKAGES_petalinux-qt = "packagegroup-xilinx-qt"
FEATURE_PACKAGES_petalinux-qt[optional] = "1"
FEATURE_PACKAGES_petalinux-opencv = "packagegroup-opencv"
FEATURE_PACKAGES_petalinux-opencv[optional] = "1"
FEATURE_PACKAGES_petalinux-benchmarks = "packagegroup-xilinx-benchmarks"
FEATURE_PACKAGES_petalinux-benchmarks[optional] = "1"
FEATURE_PACKAGES_petalinux-gstreamer = "packagegroup-xilinx-gstreamer"
FEATURE_PACKAGES_petalinux-gstreamer[optional] = "1"
FEATURE_PACKAGES_petalinux-audio = "packagegroup-xilinx-audio"
FEATURE_PACKAGES_petalinux-audio[optional] = "1"
FEATURE_PACKAGES_petalinux-xen = "packagegroup-xen"
FEATURE_PACKAGES_petalinux-xen[optional] = "1"
FEATURE_PACKAGES_petalinux-openamp = "packagegroup-openamp"
FEATURE_PACKAGES_petalinux-openamp[optional] = "1"
FEATURE_PACKAGES_petalinux-multimedia = "packagegroup-xilinx-multimedia"
FEATURE_PACKAGES_petalinux-multimedia[optional] = "1"
FEATURE_PACKAGES_petalinux-networking-stack = "packagegroup-networking-stack"
FEATURE_PACKAGES_petalinux-networking-stack[optional] = "1"
FEATURE_PACKAGES_petalinux-qt-extended = "packagegroup-xilinx-qt-extended"
FEATURE_PACKAGES_petalinux-qt-extended[optional] = "1"
FEATURE_PACKAGES_petalinux-v4lutils = "v4l-utils yavta"
FEATURE_PACKAGES_petalinux-v4lutils[optional] = "1"
FEATURE_PACKAGES_petalinux-lmsensors = "packagegroup-lmsensors"
FEATURE_PACKAGES_petalinux-lmsensors[optional] = "1"
FEATURE_PACKAGES_petalinux-jupyter = "packagegroup-xilinx-jupyter"
FEATURE_PACKAGES_petalinux-jupyter[optional] = "1"
FEATURE_PACKAGES_petalinux-ros = "packagegroup-xilinx-ros"
FEATURE_PACKAGES_petalinux-ros[optional] = "1"
#FEATURE_PACKAGES_aws-greengrass-v2 ?= "greengrass-bin-demo"
FEATURE_PACKAGES_aws-greengrass-v2 ?= "greengrass-bin"
FEATURE_PACKAGES_aws-greengrass-v2[optional] ?= "1"
