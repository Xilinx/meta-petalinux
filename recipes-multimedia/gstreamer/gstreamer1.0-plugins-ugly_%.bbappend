require gstreamer-xilinx-1.20.3.inc

S = "${WORKDIR}/git/subprojects/gst-plugins-ugly"
