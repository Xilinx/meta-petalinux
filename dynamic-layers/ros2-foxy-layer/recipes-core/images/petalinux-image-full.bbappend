require petalinux-image-common-ros2.inc

IMAGE_FEATURES:append:aarch64 = " petalinux-ros2"
