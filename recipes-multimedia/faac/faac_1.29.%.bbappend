HOMEPAGE = "http://www.audiocoding.com/faac.html"

LICENSE_FLAGS = "commercial"
LIC_FILES_CHKSUM:append = " file://README;md5=1b57f0cd75e553f79714e9894b23aabe"
