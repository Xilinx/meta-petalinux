FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI+=" \
    file://0001-Ultra96-Add-support-for-ultra96.patch \
"

