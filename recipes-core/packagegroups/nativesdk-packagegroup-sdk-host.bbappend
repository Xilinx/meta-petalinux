RDEPENDS:${PN}:append = "\
	nativesdk-qemu-xilinx \
"
