PACKAGECONFIG:append = " vpx"
