require qemu-tpm.inc
require qemu-xen.inc
