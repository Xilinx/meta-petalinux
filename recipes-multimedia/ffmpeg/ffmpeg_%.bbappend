PACKAGECONFIG:append:class-target = " \
    avresample \
    jack \
    libvorbis \
    openssl \
    sdl2 \
    speex \
    vpx \
    "
