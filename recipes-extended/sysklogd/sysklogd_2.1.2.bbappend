FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://enable-kernel-to-console.patch"
