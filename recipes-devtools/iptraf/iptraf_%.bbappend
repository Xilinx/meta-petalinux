EXTRA_OEMAKE_append = " 'LDOPTS=${LDFLAGS}' 'CFLAGS=${CFLAGS}'"
