require petalinux-image-common-accelize.inc
