FILESEXTRAPATHS_prepend  := "${THISDIR}/files:"
SRC_URI += "file://OEToolchainConfig.cmake"

